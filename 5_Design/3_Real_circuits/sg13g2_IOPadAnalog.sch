v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {opin.sym} 150 -60 0 0 {name=p1 lab=padres}
C {ipin.sym} 70 -60 0 0 {name=p2 lab=pad}
C {iopin.sym} 100 20 0 0 {name=p3 lab=vdd}
C {iopin.sym} 100 40 0 0 {name=p4 lab=vss}
C {iopin.sym} 100 60 0 0 {name=p5 lab=iovdd}
C {iopin.sym} 100 80 0 0 {name=p6 lab=iovss}
