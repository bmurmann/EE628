v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Boris Murmann"}
C {template_idsm2.sym} 760 -1140 2 0 {name=x33}
C {/foss/designs/EE628/5_Design/3_Real_circuits/padring.sym} 370 -720 0 0 {name=x1}
